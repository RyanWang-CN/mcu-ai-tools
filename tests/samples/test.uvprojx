# Keil uVision project test.uvprojx, settings and files
target TestTarget ()
  device: HC32L021
  group Source
    ./: 
